# Keil uVision project IR_Remote.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: IR_Remote +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Users;.\Users
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./Users/: nec_ir.c nec_ir.h stdutils.h
